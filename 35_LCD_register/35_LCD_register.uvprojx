# Keil uVision project 35_LCD_register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\arm5_compiler)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_led_on_register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=5 wLevel=2
  c include: .\Start;.\User;.\Hardware\LED;.\Hardware\KEY;.\Hardware\USART;.\Hardware\I2C;.\Hardware\SYSTICK;.\Hardware\TIM;.\Hardware\DMA;.\Hardware\ADC;.\Hardware\SPI;.\Hardware\FSMC;.\Interface\EEPROM;.\Interface\BUZZER;.\Interface\FLASH;.\Interface\LCD
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ./User/: main.c delay.c delay.h
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Hardware/LED
    ./Hardware/LED/: led.c led.h
  group Hardware/KEY
    ./Hardware/KEY/: key.c key.h
  group Hardware/USART
    ./Hardware/USART/: usart.c usart.h
  group Hardware/I2C
    ./Hardware/I2C/: hard_I2C.c hard_I2C.h
  group Hardware/SYSTICK
    ./Hardware/SYSTICK/: systick.c systick.h
  group Hardware/TIM
    ./Hardware/TIM/: tim6.c tim6.h tim5.c tim5.h tim4.c tim4.h tim1.c tim1.h tim3.c tim3.h
  group Hardware/DMA
    ./Hardware/DMA/: usart1_dma.c usart1_dma.h
  group Hardware/ADC
    ./Hardware/ADC/: adc1.c adc1.h
  group Hardware/SPI
    ./Hardware/SPI/: soft_spi.c soft_spi.h
  group Hardware/FSMC
    ./Hardware/FSMC/: fsmc_bank1_3_sram.c fsmc_bank1_3_sram.h
  group Interface/EEPROM
    ./Interface/EEPROM/: M24C02.c M24C02.h
  group Interface/BUZZER
    ./Interface/BUZZER/: MLT8530.c MLT8530.h
  group Interface/FLASH
    ./Interface/FLASH/: W25Q32.c W25Q32.h
  group Interface/LCD
    ./Interface/LCD/: lcd.c lcd.h lcd_font.h
